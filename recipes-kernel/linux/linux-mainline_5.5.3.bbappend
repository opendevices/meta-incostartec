FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append_plilly-a20 = "file://0001-ARM-dts-Add-dts-for-INCOstartec-pLILLY-A20.patch \
                             file://defconfig \
                            "
